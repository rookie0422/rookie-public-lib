# Keil uVision project eventdriver.uvprojx, settings and files
target eventdriver (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F103C8 Geehy
  pack: Geehy.APM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: eventdriver +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../easylogger/inc;../user;../user/mem;..\user\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group EasyLogger
    ../easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../easylogger/port/: elog_port.c
  group mem
    ../user/mem/: tlsf.c
  group user
    ../user/: app.c bsp.c dht11.c uart_interface.c os_port.c vkey.c vmsgexec.c vchannel.c vlist.c
  group lcd
    ../user/lcd/: cmd_queue.c hmi_driver.c hmi_user_uart.c
software components: CMSIS:CORE 5.5.0, CMSIS:RTOS:Keil RTX 4.82.0
